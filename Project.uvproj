# Keil uVision project Project.uvproj, settings and files
target LED Rotary Dimmer (ARM-ADS)
  device: STM32F051K4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LED_Rotary_Dimmer +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --c99
  c include: .\user;.\CMSIS\Include;.\STM32F0xx_HAL_Driver\Inc;.\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Project
    ./: BUGS.txt TODO.txt
  group Startup - CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h stm32f051x8.h system_stm32f0xx.h
    ./CMSIS/Device/ST/STM32F0xx/Source/: system_stm32f0xx.c startup_stm32f051x8.s
    ./CMSIS/Lib/ARM/: arm_cortexM0l_math.lib
    ./CMSIS/Include/: arm_math.h core_cm0.h core_cmSimd.h
  group User
    ./user/: main.c main.h InitMCU.c InitMCU.h interrupts.c interrupts.h memories.c memories.h eeprom_M24C.c eeprom_M24C.h encoder.c encoder.h
  group STM32F051
    ./STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_wwdg.c
    ./STM32F0xx_HAL_Driver/Inc/: stm32f0xx_hal_conf.h
